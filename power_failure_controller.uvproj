# Keil uVision project power_failure_controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: power_failure_controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: power_controller_000.a51
